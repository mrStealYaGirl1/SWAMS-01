#include "TextUI.h"
#include "TFTdriver.h"

static const uint8_t font5x7[][5] = {
	// SPACE
	{0x00,0x00,0x00,0x00,0x00}, // 0

	// A-Z
	{0x7E,0x09,0x09,0x09,0x7E}, // A 1
	{0x7F,0x49,0x49,0x49,0x36}, // B 2
	{0x3E,0x41,0x41,0x41,0x22}, // C 3
	{0x7F,0x41,0x41,0x22,0x1C}, // D 4
	{0x7F,0x49,0x49,0x49,0x41}, // E 5
	{0x7F,0x09,0x09,0x09,0x01}, // F 6
	{0x3E,0x41,0x49,0x49,0x7A}, // G 7
	{0x7F,0x08,0x08,0x08,0x7F}, // H 8
	{0x00,0x41,0x7F,0x41,0x00}, // I 9
	{0x20,0x40,0x41,0x3F,0x01}, // J 10
	{0x7F,0x08,0x14,0x22,0x41}, // K 11
	{0x7F,0x40,0x40,0x40,0x40}, // L 12
	{0x7F,0x02,0x04,0x02,0x7F}, // M 13
	{0x7F,0x04,0x08,0x10,0x7F}, // N 14
	{0x3E,0x41,0x41,0x41,0x3E}, // O 15
	{0x7F,0x09,0x09,0x09,0x06}, // P 16
	{0x3E,0x41,0x51,0x21,0x5E}, // Q 17
	{0x7F,0x09,0x19,0x29,0x46}, // R 18
	{0x46,0x49,0x49,0x49,0x31}, // S 19
	{0x01,0x01,0x7F,0x01,0x01}, // T 20
	{0x3F,0x40,0x40,0x40,0x3F}, // U 21
	{0x1F,0x20,0x40,0x20,0x1F}, // V 22
	{0x7F,0x20,0x18,0x20,0x7F}, // W 23
	{0x63,0x14,0x08,0x14,0x63}, // X 24
	{0x03,0x04,0x78,0x04,0x03}, // Y 25
	{0x61,0x51,0x49,0x45,0x43}, // Z 26

	// 0-9
	{0x3E,0x51,0x49,0x45,0x3E}, // 0
	{0x00,0x42,0x7F,0x40,0x00}, // 1
	{0x42,0x61,0x51,0x49,0x46}, // 2
	{0x21,0x41,0x45,0x4B,0x31}, // 3
	{0x18,0x14,0x12,0x7F,0x10}, // 4
	{0x27,0x45,0x45,0x45,0x39}, // 5
	{0x3C,0x4A,0x49,0x49,0x30}, // 6
	{0x01,0x71,0x09,0x05,0x03}, // 7
	{0x36,0x49,0x49,0x49,0x36}, // 8
	{0x06,0x49,0x49,0x29,0x1E}, // 9

	// punctuation
	{0x00,0x36,0x36,0x00,0x00}, // : 37
	{0x08,0x08,0x08,0x08,0x08}, // - 38
	{0x14,0x14,0x14,0x14,0x14}, // = 39
	{0x00,0x00,0x5F,0x00,0x00}, // ! 40
	{0x00,0x60,0x60,0x00,0x00}  // . 41
};

static int font_index(char c)
{
	if (c == ' ') return 0;
	if (c >= 'A' && c <= 'Z') return 1 + (c - 'A');
	if (c >= '0' && c <= '9') return 27 + (c - '0');
	if (c == ':') return 37;
	if (c == '-') return 38;
	if (c == '=') return 39;
	if (c == '!') return 40;
	if (c == '.') return 41;
	return 0;
}

static void draw_pixel_block(uint16_t x, uint16_t y,
uint8_t r, uint8_t g, uint8_t b,
uint8_t scale)
{
	TFTFillRectangle(x, y, scale, scale, r, g, b);
}

void TextUI_DrawChar(uint16_t x, uint16_t y, char c,
uint8_t r, uint8_t g, uint8_t b,
uint8_t bgR, uint8_t bgG, uint8_t bgB,
uint8_t scale)
{
	int idx = font_index(c);
	uint8_t col, row;
	uint8_t bits;

	for (col = 0; col < 5; col++) {
		bits = font5x7[idx][col];
		for (row = 0; row < 7; row++) {
			if (bits & (1 << row)) {
				draw_pixel_block(x + col * scale, y + row * scale, r, g, b, scale);
				} else {
				draw_pixel_block(x + col * scale, y + row * scale, bgR, bgG, bgB, scale);
			}
		}
	}

	// 1 kolonne spacing
	TFTFillRectangle(x + 5 * scale, y, scale, 7 * scale, bgR, bgG, bgB);
}

void TextUI_DrawString(uint16_t x, uint16_t y, const char* s,
uint8_t r, uint8_t g, uint8_t b,
uint8_t bgR, uint8_t bgG, uint8_t bgB,
uint8_t scale)
{
	while (*s) {
		TextUI_DrawChar(x, y, *s, r, g, b, bgR, bgG, bgB, scale);
		x += 6 * scale;
		s++;
	}
}

void TextUI_DrawUInt16(uint16_t x, uint16_t y, uint16_t value, uint8_t r, uint8_t g, uint8_t b, uint8_t bgR, uint8_t bgG, uint8_t bgB, uint8_t scale)
{
	char buf[6];
	int i = 0;
	int j;

	if (value == 0) {
		buf[0] = '0';
		buf[1] = '\0';
		TextUI_DrawString(x, y, buf, r, g, b, bgR, bgG, bgB, scale);
		return;
	}

	while (value > 0 && i < 5) {
		buf[i++] = (char)('0' + (value % 10));
		value /= 10;
	}
	buf[i] = '\0';

	for (j = 0; j < i / 2; j++) {
		char t = buf[j];
		buf[j] = buf[i - 1 - j];
		buf[i - 1 - j] = t;
	}

	TextUI_DrawString(x, y, buf, r, g, b, bgR, bgG, bgB, scale);
}